# Keil uVision project BL_HID_UART.uvproj, settings and files
target BL_HID_UART (ARM-ADS)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC123_BL_HID_UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\Library\StdDriver\inc;..\..\..\MyLibrary\HAL_Driver;..\..\..\MyLibrary\ISP_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\scatter.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
    ../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
  group User
    ../HID_UART/: descriptors.c main.c usbd_transfer.c
  group Library
    ../../../Library/StdDriver/src/: usbd.c
  group MyLibrary
    ../../../MyLibrary/ISP_Driver/: fmc_user.c isp_user.c uart_transfer.c
