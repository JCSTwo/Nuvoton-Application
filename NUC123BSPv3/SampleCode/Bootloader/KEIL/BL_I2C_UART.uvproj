# Keil uVision project BL_I2C_UART.uvproj, settings and files
target BL_I2C_UART (ARM-ADS)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC123_BL_I2C0_UART1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\;..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\MyLibrary\HAL_Driver;..\..\..\MyLibrary\ISP_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\scatter.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../I2C_UART/: main.c
  group MyLibrary
    ../../../MyLibrary/ISP_Driver/: fmc_user.c i2c_transfer.c isp_user.c uart_transfer.c
