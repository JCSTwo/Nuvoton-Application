# Keil uVision project ISP_Bridge_HID20.uvproj, settings and files
target ISP_Bridge_HID20 (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: M480_HID20_TO_ISP_BRIDGE
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc;..\;..\..\..\MyLibrary\HAL_Driver;..\..\..\MyLibrary\;..\ISP_HID_20\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../ISP_HID_20/: main.c descriptors.c hid_transfer.c
    ../: isp_bridge.c
  group Library
    ../../../Library/StdDriver/src/: can.c usci_i2c.c
  group HAL_Driver
    ../../../MyLibrary/HAL_Driver/: hal_sys.c hal_spi.c hal_usci_i2c.c hal_hsusbd.c hal_rs485.c hal_can_isp.c
    ../../../MyLibrary/ISP_Driver/: hsusbd_user.c
